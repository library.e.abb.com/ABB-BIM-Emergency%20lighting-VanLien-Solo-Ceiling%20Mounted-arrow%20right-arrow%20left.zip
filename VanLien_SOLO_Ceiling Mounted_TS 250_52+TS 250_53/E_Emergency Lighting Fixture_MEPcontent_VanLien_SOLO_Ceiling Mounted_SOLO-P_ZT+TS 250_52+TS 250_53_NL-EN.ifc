Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-12-03T12:21:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 03 12:21:50 2019 * Host: DLICA-RO-DE * Database: C:\Users\dlica\AppData\Local\Temp\{1EA89338-250E-486A-BDC2-F7D8EFE7684D}\ifc * Database version: 5507 * Database creation date: Tue Dec 03 12:21:45 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Dec 03 12:21:45 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 03 12:21:45 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcLightFixture: SOLO-P/ZT+TS 250/52+TS 250/53, E_Emergency Lighting Fixture_MEPcontent_VanLien_SOLO_Ceiling Mounted_NL-EN:SOLO-P/ZT+TS 250/52+TS 250/53:1309825
In: V00
Type - PredefinedType: POINTSOURCE; Material: Color RGB 000-127-063, Color RGB 255-255-255, Color RGB 235-235-235
Type - Dimensions - Depth: 46 mm; Height: 190 mm; Rotation U-Axis Correction: 180 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Width: 269 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC
Type - Electrical - Loads - Apparent Load: 0 W
Type - Electrical Engineering - Voltage: 230 V
Type - Identity Data - Article Description: Emergency lighting fixture arrow right-arrow right; Article Type: SOLO-P/ZT+TS 250/52+TS 250/53; Base Family Version: 12.07; Category: EL_LIGHTFIXTURE; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Emergency lighting fixture arrow right-arrow right; EMCS Version: 4.0; ETIM Article Class: EC001957; Family Version: 12.07; GLN: 8713812000008; GTIN: 08713812762340+08713812764450+08713812764467; Manufacturer: VanLien; Manufacturer Art. No.: 6331031+12525052+12525053; Manufacturer URL: http://www.vanlien.nl/ps/fulltilt/vanlien.cgi?co=NL&lang=en&part=12525052; MEPcontent Class: EMERGENCY_LIGHTING_FIXTURE; Model: SOLO-P/ZT+TS 250/52+TS 250/53; OmniClass Number: 23.80.70.11.21; OmniClass Title: Emergency Lighting; Product Line: VanLien; Revit Version: 2017; Type Name: SOLO-P/ZT+TS 250/52+TS 250/53; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Lighting Fixtures; Back Arrow Down: no; Back Arrow Left: no; Back Arrow Right: yes; Back Arrow Up: no; Back No Arrow: no; Family Name: E_Emergency Lighting Fixture_MEPcontent_VanLien_SOLO_Ceiling Mounted_NL-EN; Front Arrow Down: no; Front Arrow Left: no; Front Arrow Right: yes; Front Arrow Up: no
Type - Pset_LightFixtureTypeCommon - Reference: SOLO-P/ZT+TS 250/52+TS 250/53
Pset_ManufacturerTypeInformation - Manufacturer: VanLien
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Offset: 0 mm
Dimensions - Area: 0.418458 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.00215395 m3
Electrical - Circuiting - Electrical Data: Power - Balanced 230 V/1-0 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Loads - Load Classification: Power; Power: 0 W
Identity Data - Design Option: Main Model; Function Code: E6350; Mark: 7
Other - Family: E_Emergency Lighting Fixture_MEPcontent_VanLien_SOLO_Ceiling Mounted_NL-EN: SOLO-P/ZT+TS 250/52+TS 250/53; Family and Type: E_Emergency Lighting Fixture_MEPcontent_VanLien_SOLO_Ceiling Mounted_NL-EN: SOLO-P/ZT+TS 250/52+TS 250/53; Type: E_Emergency Lighting Fixture_MEPcontent_VanLien_SOLO_Ceiling Mounted_NL-EN: SOLO-P/ZT+TS 250/52+TS 250/53; Type Id: E_Emergency Lighting Fixture_MEPcontent_VanLien_SOLO_Ceiling Mounted_NL-EN: SOLO-P/ZT+TS 250/52+TS 250/53
Phasing - Phase Created: 4. Plan over 10 years
